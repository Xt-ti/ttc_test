# IAR project PeripheralTest.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 51
  General.FPU2: 5
  ICCARM.CCIncludePath2: ..\FM_QL_bsp\include; ..\FM_QL_bsp\bootloader; ..\FM_QL_bsp\libsrc\canps_v1_0; ..\FM_QL_bsp\libsrc\common_v1_0; ..\FM_QL_bsp\libsrc\ddr3ps_v1_0; ..\FM_QL_bsp\libsrc\devcps_v1_0; ..\FM_QL_bsp\libsrc\dmaps_v1_0; ..\FM_QL_bsp\libsrc\gicps_v1_0; ..\FM_QL_bsp\libsrc\gmacps_v1_0; ..\FM_QL_bsp\libsrc\gmacps_v1_0\phy; ..\FM_QL_bsp\libsrc\gpiops_v1_0; ..\FM_QL_bsp\libsrc\gtcps_v1_0; ..\FM_QL_bsp\libsrc\i2cps_v1_0; ..\FM_QL_bsp\libsrc\nfcps_v1_0; ..\FM_QL_bsp\libsrc\qspips_v1_0; ..\FM_QL_bsp\libsrc\sdmmcps_v1_0; ..\FM_QL_bsp\libsrc\smcps_v1_0; ..\FM_QL_bsp\libsrc\spips_v1_0; ..\FM_QL_bsp\libsrc\ttcps_v1_0; ..\FM_QL_bsp\libsrc\uartps_v1_0; ..\FM_QL_bsp\libsrc\wdtps_v1_0; ..\FM_QL_bsp\libsrc\slcrps_v1_0; ..\FM_QL_bsp\libsrc\usbps_v1_0; FM_QL_peripheraltest; FM_QL_hw_platform; $PROJ_DIR$
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: PeripheralTest.srec
  ILINK.IlinkOutputFile: PeripheralTest.out
  ILINK.IlinkIcfFile: a7_axisram.icf
  ILINK.IlinkProgramEntryLabel: resetHandler
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: ..\FM_QL_bsp\libsrc\common_v1_0; ..\FM_QL_bsp\include; FM_QL_hw_platform; ..\FM_QL_bsp\bootloader; ..\FM_QL_bsp\libsrc\canps_v1_0; ..\FM_QL_bsp\libsrc\common_v1_0; ..\FM_QL_bsp\libsrc\ddr3ps_v1_0; ..\FM_QL_bsp\libsrc\devcps_v1_0; ..\FM_QL_bsp\libsrc\dmaps_v1_0; ..\FM_QL_bsp\libsrc\gicps_v1_0; ..\FM_QL_bsp\libsrc\gmacps_v1_0; ..\FM_QL_bsp\libsrc\gmacps_v1_0\phy; ..\FM_QL_bsp\libsrc\gpiops_v1_0; ..\FM_QL_bsp\libsrc\gtcps_v1_0; ..\FM_QL_bsp\libsrc\i2cps_v1_0; ..\FM_QL_bsp\libsrc\nfcps_v1_0; ..\FM_QL_bsp\libsrc\qspips_v1_0; ..\FM_QL_bsp\libsrc\sdmmcps_v1_0; ..\FM_QL_bsp\libsrc\smcps_v1_0; ..\FM_QL_bsp\libsrc\spips_v1_0; ..\FM_QL_bsp\libsrc\ttcps_v1_0; ..\FM_QL_bsp\libsrc\uartps_v1_0; ..\FM_QL_bsp\libsrc\wdtps_v1_0; ..\FM_QL_bsp\libsrc\slcrps_v1_0; FM_QL_peripheraltest; $PROJ_DIR$
  ICCARM.CCOptLevel: 3
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group FM_QL_bsp/ps_a7/bootloader
    ../FM_QL_bsp/bootloader/: cache.c cache.h cstartup.s exception_handler.c exception_handler.h mmu_table.s
  group FM_QL_bsp/ps_a7/include
    ../FM_QL_bsp/include/: fmsh_ps_parameters.h
  group FM_QL_bsp/ps_a7/libsrc/canps_v1_0
    ../FM_QL_bsp/libsrc/canps_v1_0/: fmsh_can.c fmsh_can_common.h fmsh_can_g.c fmsh_can_lib.h fmsh_can_private.h fmsh_can_public.h fmsh_can_sinit.c
  group FM_QL_bsp/ps_a7/libsrc/common_v1_0
    ../FM_QL_bsp/libsrc/common_v1_0/: fmsh_common.c fmsh_common.h fmsh_common_bitops.h fmsh_common_dbc.h fmsh_common_delay.h fmsh_common_dev.h fmsh_common_io.h fmsh_common_list.h fmsh_common_status.h fmsh_common_types.h
  group FM_QL_bsp/ps_a7/libsrc/ddr3ps_v1_0
    ../FM_QL_bsp/libsrc/ddr3ps_v1_0/: fmsh_testmem.c fmsh_testmem.h
  group FM_QL_bsp/ps_a7/libsrc/devcps_v1_0
    ../FM_QL_bsp/libsrc/devcps_v1_0/: fmsh_devc.c fmsh_devc_common.h fmsh_devc_g.c fmsh_devc_lib.h fmsh_devc_private.h fmsh_devc_public.h fmsh_devc_sinit.c
  group FM_QL_bsp/ps_a7/libsrc/dmaps_v1_0
    ../FM_QL_bsp/libsrc/dmaps_v1_0/: fmsh_dmac.c fmsh_dmac.h fmsh_dmac_g.c fmsh_dmac_hw.h fmsh_dmac_lib.h fmsh_dmac_private.h fmsh_dmac_pub.h fmsh_dmac_sinit.c
  group FM_QL_bsp/ps_a7/libsrc/gicps_v1_0
    ../FM_QL_bsp/libsrc/gicps_v1_0/: fmsh_gic.c fmsh_gic.h fmsh_gic_hw.h fmsh_gic_intr.c fmsh_gic_sinit.c
  group FM_QL_bsp/ps_a7/libsrc/gmacps_v1_0
    ../FM_QL_bsp/libsrc/gmacps_v1_0/: fmsh_gmac_g.c fmsh_gmac_hw.c fmsh_gmac_hw.h fmsh_gmac_lib.c fmsh_gmac_lib.h fmsh_gmac_sinit.c
  group FM_QL_bsp/ps_a7/libsrc/gmacps_v1_0/phy
    ../FM_QL_bsp/libsrc/gmacps_v1_0/phy/: fmsh_mdio.c fmsh_mdio.h marvell_88e1111.c marvell_88e1111.h marvell_88e1116r.c marvell_88e1116r.h microchip_ksz9031RNX.c microchip_ksz9031RNX.h
  group FM_QL_bsp/ps_a7/libsrc/gpiops_v1_0
    ../FM_QL_bsp/libsrc/gpiops_v1_0/: fmsh_gpio.c fmsh_gpio_common.h fmsh_gpio_g.c fmsh_gpio_lib.h fmsh_gpio_private.h fmsh_gpio_public.h fmsh_gpio_sinit.c
  group FM_QL_bsp/ps_a7/libsrc/gtcps_v1_0
    ../FM_QL_bsp/libsrc/gtcps_v1_0/: fmsh_gtc.c fmsh_gtc_common.h fmsh_gtc_g.c fmsh_gtc_lib.h fmsh_gtc_private.h fmsh_gtc_public.h fmsh_gtc_sinit.c
  group FM_QL_bsp/ps_a7/libsrc/i2cps_v1_0
    ../FM_QL_bsp/libsrc/i2cps_v1_0/: fmsh_i2c.c fmsh_i2c_common.h fmsh_i2c_g.c fmsh_i2c_lib.h fmsh_i2c_private.h fmsh_i2c_public.h fmsh_i2c_sinit.c
  group FM_QL_bsp/ps_a7/libsrc/nfcps_v1_0
    ../FM_QL_bsp/libsrc/nfcps_v1_0/: fmsh_nfcps.c fmsh_nfcps.h fmsh_nfcps_bbm.c fmsh_nfcps_bbm.h fmsh_nfcps_flash.c fmsh_nfcps_flash.h fmsh_nfcps_g.c fmsh_nfcps_hw.c fmsh_nfcps_hw.h fmsh_nfcps_lib.h fmsh_nfcps_model.c fmsh_nfcps_model.h fmsh_nfcps_sinit.c fmsh_nfcps_skipblock.c fmsh_nfcps_skipblock.h fmsh_nfcps_sw.c fmsh_nfcps_sw.h
  group FM_QL_bsp/ps_a7/libsrc/qspips_v1_0
    ../FM_QL_bsp/libsrc/qspips_v1_0/: fmsh_qspips.c fmsh_qspips.h fmsh_qspips_flash.c fmsh_qspips_flash.h fmsh_qspips_g.c fmsh_qspips_hw.c fmsh_qspips_hw.h fmsh_qspips_lib.h fmsh_qspips_sinit.c fmsh_qspips_sw.c fmsh_qspips_sw.h
  group FM_QL_bsp/ps_a7/libsrc/sdmmcps_v1_0
    ../FM_QL_bsp/libsrc/sdmmcps_v1_0/: fmsh_sdmmc.c fmsh_sdmmc.h fmsh_sdmmc_g.c fmsh_sdmmc_hw.h fmsh_sdmmc_lib.h fmsh_sdmmc_private.h fmsh_sdmmc_protocol.c fmsh_sdmmc_protocol.h fmsh_sdmmc_sinit.c
  group FM_QL_bsp/ps_a7/libsrc/slcrps_v1_0
    ../FM_QL_bsp/libsrc/slcrps_v1_0/: fmsh_slcr.c fmsh_slcr.h
  group FM_QL_bsp/ps_a7/libsrc/smcps_v1_0
    ../FM_QL_bsp/libsrc/smcps_v1_0/: fmsh_smc.c fmsh_smc.h fmsh_smc_amd.c fmsh_smc_amd.h fmsh_smc_api.c fmsh_smc_api.h fmsh_smc_cfi.c fmsh_smc_cfi.h fmsh_smc_common.c fmsh_smc_common.h fmsh_smc_hw.h fmsh_smc_intel.c fmsh_smc_intel.h fmsh_smc_lib.h
  group FM_QL_bsp/ps_a7/libsrc/spips_v1_0
    ../FM_QL_bsp/libsrc/spips_v1_0/: fmsh_spips.c fmsh_spips.h fmsh_spips_g.c fmsh_spips_hw.c fmsh_spips_hw.h fmsh_spips_lib.h fmsh_spips_sinit.c fmsh_spips_sw.c fmsh_spips_sw.h
  group FM_QL_bsp/ps_a7/libsrc/ttcps_v1_0
    ../FM_QL_bsp/libsrc/ttcps_v1_0/: fmsh_ttc.c fmsh_ttc_common.h fmsh_ttc_g.c fmsh_ttc_lib.h fmsh_ttc_private.h fmsh_ttc_public.h fmsh_ttc_sinit.c
  group FM_QL_bsp/ps_a7/libsrc/uartps_v1_0
    ../FM_QL_bsp/libsrc/uartps_v1_0/: fmsh_uart.c fmsh_uart_common.h fmsh_uart_g.c fmsh_uart_lib.h fmsh_uart_private.h fmsh_uart_public.h fmsh_uart_sinit.c
  group FM_QL_bsp/ps_a7/libsrc/usbps_v1_0
    ../FM_QL_bsp/libsrc/usbps_v1_0/: fmsh_usb_common.h fmsh_usb_core.h fmsh_usb_dev.c fmsh_usb_dev.h fmsh_usb_g.c fmsh_usb_lib.h fmsh_usb_private.h fmsh_usb_sinit.c
  group FM_QL_bsp/ps_a7/libsrc/wdtps_v1_0
    ../FM_QL_bsp/libsrc/wdtps_v1_0/: fmsh_wdt.c fmsh_wdt_common.h fmsh_wdt_g.c fmsh_wdt_lib.h fmsh_wdt_private.h fmsh_wdt_public.h fmsh_wdt_sinit.c
  group FM_QL_hw_platform
    FM_QL_hw_platform/: ps_init.c ps_init.h
  group FM_QL_peripheraltest
    FM_QL_peripheraltest/: fmsh_can_example.c fmsh_can_example.h fmsh_dmac_example.c fmsh_dmac_example.h fmsh_gic_selftest.c fmsh_gmac_example.c fmsh_gmac_example.h fmsh_gpio_example.c fmsh_gpio_example.h fmsh_i2c_example.c fmsh_i2c_example.h fmsh_nfc_example.c fmsh_nfc_example.h fmsh_qspi_example.c fmsh_qspi_example.h fmsh_sdmmc_example.c fmsh_sdmmc_example.h fmsh_smc_example.c fmsh_smc_example.h fmsh_spi_example.c fmsh_spi_example.h fmsh_ttc_example.c fmsh_ttc_example.h fmsh_uart_example.c fmsh_uart_example.h fmsh_usb_example.c fmsh_usb_example.h PeripheralTest.c
